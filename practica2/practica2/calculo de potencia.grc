options:
  parameters:
    author: uis
    generate_options: qt_gui
    id: calculo_de_potencia
    output_language: python
    title: calculo_de_potencia
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: amplitud
    start: '0'
    step: '0.00001'
    stop: '1'
    value: '1'
  states: {}
- name: AP
  id: variable_qtgui_range
  parameters:
    label: amplitud Portadora
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: KA
  id: variable_qtgui_range
  parameters:
    label: Coeficiente KA
    start: '0'
    step: '0.00001'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: Envolvente_DSB_0
  id: Envolvente_DSB
  parameters:
    Ac: AP
    Ka: KA
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: lab2_punto1_0
  id: lab2_punto1
  parameters:
    I_vect: '1024'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '50000000'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_DSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_DSB_0, '0']
- [analog_sig_source_x_0, '0', lab2_punto1_0, '0']

metadata:
  file_format: 1
